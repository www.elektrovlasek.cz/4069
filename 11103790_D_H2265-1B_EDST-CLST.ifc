Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-15T14:59:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 15 14:59:51 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F7A89181-C659-407B-8750-B055E516CFF6}\ifc * Database version: 5507 * Database creation date: Mon Apr 15 14:59:50 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 15 14:59:51 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 15 14:59:51 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22226594_D_11103790_H2265-1B_EDST-CLST, 11103790_D_H2265-1B_EDST-CLST:22226594_D_11103790_H2265-1B_EDST-CLST:205924
In: Level 1
Type - Classification: H2000B (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Alusilver, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22226594_D_11103790_H2265-1B_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
